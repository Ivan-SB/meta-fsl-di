FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-imx28-evk.dts-4.3-display-parameters.patch \
            file://0001-imx28-evk.dts-enable-UART-0123-2-pin-configuration.patch \
"

